# Keil uVision project Projet_FreeRTOS.uvprojx, settings and files
target Projet (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Projet_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\Keil_Files;..\Librairies\STM32F4xx_StdPeriph_Driver\inc;..\FreeRTOS\Source\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ../Librairies/: startup_stm32f4xx.s
    ../Librairies/STM32F4xx_StdPeriph_Driver/src/: system_stm32f4xx.c
  group Libraires
    ../Librairies/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_tim.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_exti.c
  group User
    ./: Configuration.c Principal.c
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c heap_2 _ARM_CM4F.c list.c port_ARM_CM4F.c queue.c tasks.c timers.c
